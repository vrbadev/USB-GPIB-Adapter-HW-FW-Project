# Keil uVision project f103_usb_gpib.uvprojx, settings and files
target STM32F103C6 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: f103_usb_gpib +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: F_CPU=48000000UL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group src
    ./: delay.c gpio.c main.c usblib.c startup_stm32f103x6.s gpib.c
  group inc
    ./: delay.h gpio.h stm32f103x6.h usblib.h gpib.h
software components: CMSIS:CORE 5.4.0
